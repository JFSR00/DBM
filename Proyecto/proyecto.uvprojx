# Keil uVision project proyecto.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proyecto
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c adc_lpc40xx.c error.c font_8x16.c font_12x24.c font_16x32.c glcd.c gpio_lpc40xx.c joystick.c leds.c sdram.c timer_lpc40xx.c uart_lpc40xx.c adc_lpc40xx.h error.h font.h glcd.h gpio_lpc40xx.h joystick.h leds.h sdram.h timer_lpc40xx.h tipos.h uart_lpc40xx.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Board Support:A/D Converter 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:Joystick 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:I2C 1.0, CMSIS Driver:SPI:SSP 1.1, CMSIS Driver:USART 1.2, CMSIS Driver:WiFi:ESP8266 1.4.0, Device:GPDMA 1.0, Device:GPIO 1.0, Device:PIN 1.0, Device:Startup 1.0.1
