# Keil uVision project HTTP_Server.uvprojx, settings and files
target LCD PB1 TFT 4.3 inch (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif llblue.jpg pabb.gif logo.gif uca150x59.gif
  group Documentation
    ./: Abstract.txt
target LCD PB1 TFT 7.0 inch (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: as above
  output: HTTP_Server
  c flags: Optim=4 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:A/D Converter 1.0.0, Board Support:Buttons 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:Web Server Compact 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:Ethernet MAC 1.0, CMSIS Driver:Ethernet PHY:LAN8720 6.1, CMSIS Driver:I2C 1.0, Device:GPIO 1.0, Device:PIN 1.0, Device:Startup 1.0.1
