# Keil uVision project proyecto.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.1.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proyecto
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: adc_lpc40xx.c error.c font_8x16.c font_12x24.c font_16x32.c glcd.c gpio_lpc40xx.c iocon_lpc40xx.c joystick.c ldr.c leds.c main.c sdram.c sonido.c teclado_4x4_interrupciones_gpio_y_timer.c timer_lpc40xx.c
  group ::Device
    RTE/Device/LPC4088FET208/: startup_LPC407x_8x_177x_8x.s system_LPC407x_8x_177x_8x.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
