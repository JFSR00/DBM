# Keil uVision project web_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: web_project
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.cpp
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/LPC4000_DFP/2.1.0/RTE_Driver/: EMAC_LPC40xx.c OTG_LPC40xx.c SSP_LPC40xx.c UART_LPC40xx.c USBH_LPC40xx.c
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/Network/Driver/: ETH_KSZ8851SNL.c PHY_DP83848C.c PHY_LAN8720.c PHY_ST802RT1.c
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/USB/Driver/: USART_PL2303.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/LPC4000_DFP/2.1.0/RTE_Driver/: GPDMA_LPC40xx.c GPIO_LPC40xx.c PIN_LPC40xx.c
    RTE/Device/LPC4088FET208/: RTE_Device.h startup_LPC407x_8x_177x_8x.s system_LPC407x_8x_177x_8x.c system_LPC407x_8x_177x_8x.h
  group ::Network
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/Network/Driver/: Modem_Standard.c
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/Network/Lib/ARM/: Net_CM3_L.lib
    RTE/Network/: Net_Config.c Net_Config_ETH_0.h Net_Config_HTTP_Server.h Net_Config_PPP.h Net_Config_TCP.h
  group ::USB
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/USB/Lib/ARM/: USB_CM3_L.lib
    RTE/USB/: USBH_Config_0.c USBH_Config_CustomClass.h
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Network:CORE 6.2.0, Network:Interface:ETH 6.2.0, Network:Interface:PPP 6.2.0, Network:Service:Web Server Compact 6.2.0, Network:Socket:TCP 6.2.0, USB:CORE 6.2.0, USB:Host 6.2.0, USB:Host:Custom Class 6.2.0, CMSIS Driver:Ethernet MAC 1.1, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:Ethernet PHY:LAN8720 6.00, CMSIS Driver:Ethernet PHY:ST802RT1 6.00, CMSIS Driver:Ethernet:KSZ8851SNL 6.01, CMSIS Driver:SPI:SSP 1.1, CMSIS Driver:USART 1.2, CMSIS Driver:USART:PL2303 1.00, CMSIS Driver:USB Host 1.0, Device:GPDMA 1.0, Device:GPIO 1.0, Device:PIN 1.0, Device:Startup 1.0.1
